options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbt_tx_demo
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 490e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (8000000.0 * 8) / 7
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '20'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\gnu dvb s2\output1.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '256'
    input_size: '8192'
    tagname: ''
  states: {}
- name: dtv_dvbt_bit_inner_interleaver_0
  id: dtv_dvbt_bit_inner_interleaver
  parameters:
    constellation: 64qam
    transmission_mode: T8k
  states: {}
- name: dtv_dvbt_convolutional_interleaver_0
  id: dtv_dvbt_convolutional_interleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_energy_dispersal_0
  id: dtv_dvbt_energy_dispersal
  parameters:
    nsize: '1'
  states: {}
- name: dtv_dvbt_inner_coder_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C2_3
    constellation: 64qam
    hierarchy: nh
    ninput: '1'
    noutput: '6048'
  states: {}
- name: dtv_dvbt_map_0
  id: dtv_dvbt_map
  parameters:
    constellation: 64qam
    gain: '1'
    hierarchy: nh
    transmission_mode: T8k
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_reference_signals_0
  id: dtv_dvbt_reference_signals
  parameters:
    cell_id: '0'
    code_rate_hp: C2_3
    code_rate_lp: C2_3
    constellation: 64qam
    guard_interval: GI_1_32
    hierarchy: nh
    include_cell_id: call_id_yes
    transmission_mode: T8k
    type: complex
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Interleave
    transmission_mode: T8k
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 490e6
    gain0: tx_gain
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    bandwidth0: '8000000'
    center_freq0: center_freq
    driver: lime
    gain0: tx_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    bandwidth: 8e6
    center_freq: center_freq
    gain: tx_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=8192,num_send_frames=128,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', dtv_dvbt_energy_dispersal_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_throttle2_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', osmosdr_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', soapy_custom_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', soapy_limesdr_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', uhd_usrp_sink_0, '0']
- [dtv_dvbt_bit_inner_interleaver_0, '0', dtv_dvbt_symbol_inner_interleaver_0, '0']
- [dtv_dvbt_convolutional_interleaver_0, '0', dtv_dvbt_inner_coder_0, '0']
- [dtv_dvbt_energy_dispersal_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [dtv_dvbt_inner_coder_0, '0', dtv_dvbt_bit_inner_interleaver_0, '0']
- [dtv_dvbt_map_0, '0', dtv_dvbt_reference_signals_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', dtv_dvbt_convolutional_interleaver_0, '0']
- [dtv_dvbt_reference_signals_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_0, '0', dtv_dvbt_map_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
